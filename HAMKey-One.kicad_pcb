# Repository HAM-Key/One-layout

File README.md:

# HAMKey-layout [WIP]

## BOM
interactive Bom: https://ham-key.github.io/One-layout/

## PCB Render

## Schematic

## KiCad design HAMKey-One.kicad_pcb

Parts:
AE1: Antenna_Shield; Texas_SWRA117D_2.4GHz_Right
BATT1: Battery_Cell; BATT-501240
BZ1: Buzzer; BUZZ-9032
C1, C2, C4, C14: 0.1uF; C_0402_1005Metric
C3: 0.47uF; C_0402_1005Metric
C5, C6, C8, C13: 1uF; C_0402_1005Metric
C7, C12: 4.7uF; C_0402_1005Metric
C9: 0.8pF; C_0402_1005Metric
C10, C11, C18, C19: 12pF; C_0402_1005Metric
C15: 100pF; C_0402_1005Metric
C16, C17: NC; C_0402_1005Metric
C20, C21: 0.47uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
D3: RED; LED_0402_1005Metric
D4: BLUE; LED_0402_1005Metric
D5: WHITE; LED_0402_1005Metric
D6: GREEN; LED_0402_1005Metric
FID1, FID2: Fiducial; marker1
H1, H2, H3, H4: M3.5; MountingHole_3.5mm_Pad_Via
J1: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
L1: 10uH; L_0603_1608Metric
L2: 15nH; L_0402_1005Metric
Q1: DTC143Z; SOT-23-3
R1, R9: 470k; R_0402_1005Metric
R2: 1M; R_0402_1005Metric
R3, R4, R5: 5.1k; R_0402_1005Metric
R6, R7, R17: 0R; R_0402_1005Metric
R10: 10k; R_0402_1005Metric
R11: 100k; R_0402_1005Metric
R12: 100R; R_0402_1005Metric
R13, R16: 390R; R_0402_1005Metric
R14: 47R; R_0402_1005Metric
R15: 75R; R_0402_1005Metric
SW1, SW4, SW5: SW_Main; KEY-1511
SW2: SW_Reset; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
SW3: SW_PWR; SS12D06G5
SW6: SW_SOUND; SK-3296S-01-L1
U1: nRF52832-QFxx; QFN-48-1EP_6x6mm_P0.4mm_EP4.6x4.6mm
U2: SLM6400; DFN-8-1EP_3x3mm_P0.65mm_EP1.55x2.4mm
U3: ME6210A33M3G; SOT-23
USB1: USB_C_Receptacle_PowerOnly_6P; Type-C-3.2H
Y1: Xtal_32M; Crystal_SMD_2016-4Pin_2.0x1.6mm
Y2: 32.768kHz; Crystal_SMD_3215-2Pin_3.2x1.5mm

Connections:
+3.3V: C1.1, C12.1, J1.4, R5.2, R9.1, R12.1, R13.2, R14.2, R15.2, R16.2, SW1.2, SW3.2 (B), SW4.2, SW5.2, U1.13 (VDD), U1.36 (VDD), U1.40 (P0.28/AIN4), U1.48 (VDD)
+5V: C8.2, R11.1, U2.4 (VCC), USB1.A9 (VBUS), USB1.B9 (VBUS)
/BAT+: BATT1.1 (+), C5.1, C6.2, R1.1, U2.5 (BAT), U3.3 (VIN)
/BTN0: C3.2, C20.2, SW1.1, SW4.1, U1.20 (P0.17)
/BTN2: C21.2, SW5.1, U1.19 (P0.16)
/BUZZER: BZ1.2 (+), U1.17 (P0.14)
/CC1: R4.1, USB1.A5 (CC1)
/CC2: R3.1, USB1.B5 (CC2)
/CHARGING: D6.1 (K), R9.2, U1.4 (P0.02/AIN0), U2.7 (~CHRG)
/LED_BLUE: D4.1 (K), U1.16 (P0.13)
/LED_RED: D3.1 (K), U1.15 (P0.12)
/LED_WHITE: D5.1 (K), U1.14 (P0.11)
/RESET: C4.2, R5.1, SW2.1, U1.24 (P0.21/~RESET)
/SWD+: R6.1, U1.25 (SWDCLK)
/SWD-: R7.1, U1.26 (SWDIO)
/SWDN: J1.3, R7.2
/SWDP: J1.2, R6.2
/SW_SOUND: SW6.2 (B), U1.10 (P0.08)
/VBUS: Q1.3 (C), U1.5 (P0.03/AIN1)
GND: AE1.2 (Shield), BATT1.2 (-), C1.2, C2.2, C3.1, C4.1, C5.2, C6.1, C7.2, C8.1, C9.2, C10.1, C11.1, C12.2, C13.2, C14.1, C15.1, C16.1, C17.2, C18.2, C19.2, C20.1, C21.1, J1.1, Q1.2 (E), R2.2, R3.2, R4.2, R10.1, SW2.2, SW3.3 (C), SW6.3 (C), U1.31 (VSS), U1.45 (VSS), U1.49 (VSS), U2.3 (GND), U2.8 (~CE), U2.9 (EP), U3.1 (GND), USB1.A12 (GND), USB1.B12 (GND), USB1.S1 (SHIELD), Y1.2, Y1.4
LDO3v3: C7.1, SW3.1 (A), SW6.1 (A), U3.2 (VOUT)
unnamed: AE1.1 (A), C17.1, R17.1
unnamed: BZ1.1 (-), R12.2
unnamed: D3.2 (A), R13.1
unnamed: D4.2 (A), R14.1
unnamed: D5.2 (A), R15.1
unnamed: D6.2 (A), R16.1
unnamed: L1.2, L2.1
unnamed: Q1.1 (B), R11.2
unnamed: C9.1, R17.2, U1.30 (ANT)
unnamed: L1.1, U1.47 (DCC)
unnamed: C14.2, U1.1 (DEC1)
unnamed: C16.2, U1.32 (DEC2)
unnamed: C15.2, U1.33 (DEC3)
unnamed: C13.1, L2.2, U1.46 (DEC4)
unnamed: C18.1, U1.2 (P0.00/XL1), Y2.2
unnamed: C19.1, U1.3 (P0.01/XL2), Y2.1
unnamed: C2.1, R1.2, R2.1, U1.41 (P0.29/AIN5)
unnamed: C10.2, U1.34 (XC1), Y1.1
unnamed: C11.2, U1.35 (XC2), Y1.3
unnamed: R10.2, U2.2 (PROG)

Notes on the sheet:
蓝牙摩斯码键盘
HAM-Key@GitHub
HAMKey-One

Board: 2 copper layers, 53.4 x 53.9 mm, 62 parts (2 on the bottom side), 40 nets.

## Commit log

2024-09-05 init commit
2024-09-10 near finish layout
2024-09-24 first production ver
2024-09-26 bom fix
